# Keil uVision project L071RBTx.uvprojx, settings and files
target L071RBTx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L071RBTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: L071RBTx +hex
  AfterMake: fromelf --bin  --output  .\L071RBTx\APP.bin  .\L071RBTx\L071RBTx.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L071xx,BUG
  c misc: --C99
  c include: ../Inc;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../Drivers/CMSIS/Include;..\FM175XX;..\Hardware;..\Application
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32l071xx.s
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_dma.c stm32l0xx_hal_gpio.c stm32l0xx_hal_flash.c stm32l0xx_hal_i2c.c stm32l0xx_hal_tim.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_uart.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_cortex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c
  group Application/User
    ../Src/: stm32l0xx_hal_msp.c stm32l0xx_it.c main.c
    ../Application/: sys.c Application.c
  group Drivers/CMSIS
    ..//Src/: system_stm32l0xx.c
  group FM175XX
    ../FM175XX/: 17522test.c FM175XX.c LPCD_API.c READER_API.c
  group Hareware
    ../Hardware/: adc.c gpio.c iwdg.c rtc.c spi.c usart.c timer.c
  group Application
    ../Application/: Bletransport.c Buzzer.c Event.c Record.c Zigbeetransport.c
    ../Hardware/: Debug.c
  group Lib
    ../Hardware/: PWR.lib LIBCRC.lib
    ../Application/: LIBStore.lib Flash.c
    ../FM175XX/: FM175xx.lib
  group dor
    ../: README.md
software components: CMSIS:CORE 5.1.1
